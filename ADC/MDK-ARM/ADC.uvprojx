# Keil uVision project ADC.uvprojx, settings and files
target ADC (6140000::V6.14::ARMCLANG)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ADC +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=5 v6LangP=8 wLevel=3
  c define: PREFETCH_ENABLE=1,STM32F103xB,HSE_VALUE=8000000,USE_FULL_LL_DRIVER
  c include: ..\code\Drivers\CMSIS\core\Include;..\code\Inc;..\code\Drivers\STM32F1\inc;..\code\Drivers\LL;..\code\Drivers\CMSIS\Device\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group driver/cmsis
    ../code/Drivers/CMSIS/Device/src/: system_stm32f1xx.c
    ./: startup_stm32f103xe.s
  group driver/LL
    ../code/Drivers/LL/: stm32f1xx_ll_adc.c stm32f1xx_ll_rcc.c stm32f1xx_ll_spi.c stm32f1xx_ll_tim.c stm32f1xx_ll_dma.c
  group drver/stm32f1
    ../code/Drivers/STM32F1/src/: stm32f1_gpio.c stm32f1_uart.c
  group src
    ../code/Src/: crc16.c gpio.c main.c modbus.c rcc.c stm32f1xx_it.c tim.c uart.c adc.c dma.c AD5270.c spi.c
software components: CMSIS:CORE 5.4.0
